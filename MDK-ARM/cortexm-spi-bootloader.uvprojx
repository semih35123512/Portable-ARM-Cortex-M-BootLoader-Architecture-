# Keil uVision project cortexm-spi-bootloader.uvprojx, settings and files
target cortexm-spi-bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.8
  cpu: IRAM(0x1FFF8000,0x2F000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cortexm-spi-bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,BOOT_MCU_HC32F460,BOOT_SPI_FW_MODE=2
  c include: ..\BootRAM\platforms\hc32f460\board;..\BootRAM;..\BootStub;..\..\Driver\cmsis\Device\HDSC\hc32f4xx\Include;..\..\Driver\cmsis\Include;..\..\Driver\hc32_ll_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  scatter file: ..\BootRAM\platforms\hc32f460\bootloader.sct
  link misc: --entry Stub_Reset_Handler --keep=Stub_Reset_Handler
  group BootStub
    ../BootStub/: boot_stub_startup.s boot_stub.c
  group BootRAM_core
    ../BootRAM/: BootRAM.c boot_port.c boot_core.c boot_storage.c boot_board.c boot_meta.c boot_config.h boot_port.h boot_mcu_select.h
  group platform_hc32f460
    ../BootRAM/platforms/hc32f460/: boot_hc32f460_ram_driver.c boot_hc32f460_driver_adapter.c boot_hc32f460_driver.h boot_port_hc32f460_impl.c boot_storage_hc32f460_impl.c boot_board_hc32f460_impl.c boot_fw_zone_hc32f460.c
  group platform_user_template
    ../BootRAM/platforms/user_template/: boot_port_user_impl.c boot_board_user_impl.c boot_hooks_user_impl.c
  group platform_hc32f460_board
    ../BootRAM/platforms/hc32f460/board/: board.h spi_flash.h flash_interface.h hc32f4xx_conf.h
    ../BootRAM/platforms/hc32f460/: boot_hc32f460_link_stubs.c
  group docs
    ../: README.md PORTING.md
